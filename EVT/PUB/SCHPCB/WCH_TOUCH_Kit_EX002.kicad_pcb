# Repository openwch/ch585

## KiCad design EVT/PUB/SCHPCB/WCH_TOUCH_Kit_EX002.kicad_pcb

Board: 2 copper layers, 66.0 x 76.3 mm, 19 parts (8 on the bottom side), 18 nets.

Parts:
LED0, LED1, LED2, LED3, LED4, LED5, LED6, LED7: LED0805-RD_EH
P1: Header 7X2; HDR-TH_14P-P2.54-H-F-R2-C10-W8.5
P2: Header 10X2; HDR-TH_20P-P2.54-H-F-R2-C10-W8.5
RB1: RB-8P4R; RCA-8P4R-0603
S0, S1, S2, S3, S4, S5, S6, S7: TK; TOUCHKEY-12mm-S

Connections:
COM1: LED0.2, LED1.2, LED2.2, LED3.2, P2.2
COM2: LED4.2, LED5.2, LED6.2, LED7.2, P2.4
SEG0: P2.7, RB1.4
SEG1: P2.5, RB1.3
SEG2: P2.3, RB1.2
SEG3: P2.1, RB1.1
SEG_0: LED0.1, LED4.1, RB1.5
SEG_1: LED1.1, LED5.1, RB1.6
SEG_2: LED2.1, LED6.1, RB1.7
SEG_3: LED3.1, LED7.1, RB1.8
TS0: P1.1, S0.1
TS1: P1.2, S4.1
TS2: P1.3, S1.1
TS3: P1.4, S5.1
TS4: P1.5, S2.1
TS5: P1.6, S6.1
TS6: P1.7, S3.1
TS7: P1.8, S7.1

## KiCad design EVT/PUB/SCHPCB/CH585M-R1/CH585M-R1-1v2.kicad_pcb

Parts:
C1: 4.7uF; 0402_C
C2, C6, C17: NC; 0402_C
C3: 10uF; 0603_C
C4, C10: 30pF 2%; 0402_C
C5, C11: 2.2uF; 0402_C
C7: 0.47uF; 0402_C
C8: 0.1uF; 0402_C
C9, C13: 100pF 2%; 0402_C
C12, C14: 200pf 2%; 0402_C
C15, C16: 10nF; 0402_C
C18: NC(可用于ESD器件); 0402_C
C19: 0.5pF; 0402_C
D1: POWER; 0603+
D2: LED0; 0603+
D3: LED1; 0603+
E1: ANTENNA; ANT-F-1-2.4G-1.6mmFR4
L1: 10uH; SMD_2x2mm
L2, L3: 1uH; 0603
L4: 0R; 0402
P1: TYPE-C FS-USB; TYPE-C-Receptacle-2.0
P2, P3: HEADER 14x2; IDC28-2.54MM
P4: TYPE-C HS-USB; TYPE-C-Receptacle-2.0
R1, R2, R3: 1K; 0402
R4, R7, R8, R11: 5.1K; 0402
R12: 1kΩ; 0402
R13, R14: 1Ω(4.7Ω); 0402
R15, R17: NC; 0402
R16: 2kΩ; 0402
S1: SW; SW1
S2: RST#; SMD_6.1x3.65x2.5mm-KEY
S3: Download; SMD_6.1x3.65x2.5mm-KEY
U1: 6219P33M; SOT-23
U2: CH585M; QFN48_5X5
U3: CH213E; SOT-23-3
Y1: 32MHz ±10ppm 12pF 30Ω; XT3225
Y2: 32.768K; fc-135

Connections:
+5V: P1.A4 (VBUS), P1.B4 (VBUS), P3.25, P3.27, P4.A4 (VBUS), P4.B4 (VBUS), S1.1
ANT: C18.2, L4.2, U2.34 (ANT)
BOOT: P3.5, S3.2, U2.26 (PB22/TMR3/RXD2_)
LED0: P2.20, R2.1
LED1: P2.22, R3.1
NFC+: L3.1, P2.21, U2.9 (PB17/NFC+)
NFC-: L2.1, P2.23, U2.10 (PB16/NFC-)
NFCI: C15.1, P2.17, R15.1, U2.7 (PB9/NFCI)
NFCM: C16.1, P2.19, R15.2, U2.8 (PB8/NFCM)
NFC_CTR: P2.18, R12.2
NetC2_1: C2.1, C9.1, C10.1, L2.2
NetC2_2: C2.2, C4.1, C13.2, L3.2
NetC4_2: C4.2, C6.2, C14.2, R13.1, R16.1
NetC10_2: C10.2, C12.1, C17.1, R14.1
NetC15_2: C15.2, R12.1, R16.2
NetC19_2: C19.2, E1.1, L4.1
NetD1_1: D1.1 (A), R1.1
NetD2_2: D2.2 (K), R2.2
NetD3_2: D3.2 (K), R3.2
NetP1_A5: P1.A5 (CC1), R4.2
NetP1_B5: P1.B5 (CC2), R7.1
NetP4_A5: P4.A5 (CC1), R8.2
NetP4_B5: P4.B5 (CC2), R11.1
NetR13_2: R13.2, R14.2, R17.1
NetS1_2: S1.2, U3.3 (VI+)
PA0: P2.4, U2.39 (PA0/SCK1/LED0/A9)
PA1: P2.5, U2.40 (PA1/MOSI1/LED1/A8)
PA2: P2.6, U2.41 (PA2/TMR3_/MISO1/RI/LED2/A7)
PA3: P2.7, U2.42 (PA3/LED3/A6)
PA4: P2.1, U2.36 (PA4/RXD3/LEDC/A0)
PA5: P2.2, U2.37 (PA5/TXD3/LED4/A1)
PA6: P2.3, U2.38 (PA6/RXD2/PWM4_/LED5/A10)
PA7: P2.16, U2.4 (PA7/TXD2/PWM5_/LED6/A11)
PA8: P2.15, U2.5 (PA8/RXD1/LED7/A12)
PA9: P2.14, U2.6 (PA9/TMR0/TXD1/A13)
PA10: P2.13, U2.48 (PA10/X32KI/TMR1), Y2.1 (OSC1)
PA11: P2.12, U2.47 (PA11/X32KO/TMR2), Y2.2 (OSC2)
PA12: P2.11, U2.46 (PA12/SCS/PWM4/A2)
PA13: P2.9, U2.45 (PA13/SCK0/PWM5/A3)
PA14: P2.10, U2.44 (PA14/MOSI/TXD0_/A4)
PA15: P2.8, U2.43 (PA15/MISO/RXD0_/A5)
PB0: P3.7, U2.24 (PB0/CTS/PWM6)
PB1: P3.8, U2.23 (PB1/DSR/PWM7_)
PB2: P3.9, U2.22 (PB2/PWM8_)
PB3: P3.10, U2.21 (PB3/DCD/PWM9_)
PB4: P3.11, U2.20 (PB4/RXD0/PWM7)
PB5: P3.12, U2.19 (PB5/DTR)
PB6: P3.13, U2.18 (PB6/RTS/PWM8)
PB7: P3.14, U2.17 (PB7/TXD0/PWM9)
PB10: P1.A7 (Dn1), P1.B7 (Dn2), P3.15, U2.16 (PB10/UD-/TMR1_)
PB11: P1.A6 (Dp1), P1.B6 (Dp2), P3.16, U2.15 (PB11/UD+/TMR2_)
PB12: P3.17, P4.A7 (Dn1), P4.B7 (Dn2), U2.14 (PB12/U2D-/SCS_/SDA/RXD1_)
PB13: P3.18, P4.A6 (Dp1), P4.B6 (Dp2), U2.13 (PB13/U2D+/SCK0_/SCL/TXD1_)
PB14: P3.19, U2.12 (PB14/TIO/MOSI_/PWM10)
PB15: P3.20, U2.11 (PB15/TCK/MISO_)
PB18: P3.1, U2.30 (PB18)
PB19: P3.2, U2.29 (PB19)
PB20: P3.3, U2.28 (PB20/SDA_/RXD3_)
PB21: P3.4, U2.27 (PB21/SCL_/TXD3_)
PB23: P3.6, S2.2, U2.25 (PB23/TMR0_/TXD2_/PWM11)
V5V: C3.1, U1.3 (Vin), U3.2 (VO-)
VCC: C11.2, P2.26, P3.21, U2.3 (VIO33/VDD33)
VDCIA: C1.1, C8.1, L1.1, U2.1 (VDCID), U2.35 (VDCIA)
VINTA: C7.1, U2.33 (VINTA)
VSW: L1.2, U2.2 (VSW)
X32MI: U2.32 (X32MI), Y1.1 (XIN)
X32MO: U2.31 (X32MO), Y1.3 (XOUT)

Notes on the sheet:
NFC
USB type C
晶振选型需与芯片内置电容值匹配
USB2 type C
L1 C1 C11尽量靠近芯片放置
C1 C11 接地与芯片接地回路优先级最高
FCC & ESD Optional

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
Board: 2 copper layers, 106.0 x 59.1 mm, 52 parts (1 on the bottom side), 69 nets.

## KiCad design EVT/PUB/SCHPCB/CH585D-DG-R0/CH585D-DG-R0-1v0.kicad_pcb

Board: 2 copper layers, 11.5 x 16.4 mm, 10 parts (1 on the bottom side), 10 nets.

Parts:
C1, C7: 1uF; 0402_C
C4, C11: 2.2uF; 0402_C
C8: 0.1uF; 0402_C
E1: ANTENNA; ANT-F-1-2.4G-0.8mmFR4
P3: USB; USBAM-4P
U1: 6219P33M; SOT-23
U2: CH585D; QFN20_3X3
Y1: 32MHz; XT2016

Connections:
+3V3: C11.2, U1.2, U2.3
+5V: C4.2, P3.1, U1.3
ANT: E1.1, U2.15
GND: C1.1, C4.1, C7.2, C8.2, C11.1, E1.0, P3.4, U1.1, U2.0, Y1.2, Y1.4
PB12: P3.2, U2.8
PB13: P3.3, U2.7
VDCIA: C1.2, C8.1, U2.1, U2.2, U2.16
VINTA: C7.1, U2.14
X32MI: U2.13, Y1.1
X32MO: U2.12, Y1.3

## Code that names these connections

File EVT/EXAM/ADC/ADC_Scan/src/Main.c:

/********************************** (C) COPYRIGHT *******************************
 * File Name          : Main.c
 * Author             : WCH
 * Version            : V1.0
 * Date               : 2026/10/13
 * Description        : ADC扫描模式例程，14通道自动扫描+DMA(注意：扫描模式下打印脚为PB7)
 *********************************************************************************
 * Copyright (c) 2021 Nanjing Qinheng Microelectronics Co., Ltd.
 * Attention: This software (modified or not) and binary are used for
 * microcontroller manufactured by Nanjing Qinheng Microelectronics.
 *******************************************************************************/

#include "CH58x_common.h"

/* 注意当使用ADC扫描功能时，例程默认打印脚由PA14更改为PB7 */
#define ADC_SCAN_CH_NUM            (14)

#define ADC_SCAN1_CH_IDX_1 (0)
#define ADC_SCAN1_CH_IDX_2 (4)
#define ADC_SCAN1_CH_IDX_3 (8)
#define ADC_SCAN1_CH_IDX_4 (12)
#define ADC_SCAN1_CH_IDX_5 (16)
#define ADC_SCAN1_CH_IDX_6 (20)
#define ADC_SCAN1_CH_IDX_7 (24)
#define ADC_SCAN1_CH_IDX_8 (28)
#define ADC_SCAN2_CH_IDX_9 (0)
#define ADC_SCAN2_CH_IDX_10 (4)
#define ADC_SCAN2_CH_IDX_11 (8)
#define ADC_SCAN2_CH_IDX_12 (12)
#define ADC_SCAN2_CH_IDX_13 (16)

const uint32_t ADC_PIN[14] = {
    0x00000010,                                           // PA4,AIN0
    0x00000020,                                           // PA5,AIN1
    0x00001000,                                           // PA12,AIN2
    0x00002000,                                           // PA13,AIN3
    0x00004000,                                           // PA14,AIN4
    0x00008000,                                           // PA15,AIN5
    0x00000008,                                           // PA3,AIN6
    0x00000004,                                           // PA2,AIN7
    0x00000002,                                           // PA1,AIN8
    0x00000001,                                           // PA0,AIN9
    0x00000040,                                           // PA6,AIN10
    0x00000080,                                           // PA7,AIN11
    0x00000100,                                           // PA8,AIN12
    0x00000200                                            // PA9,AIN13
};

const uint8_t adc_ch_seq[14] = {0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13};

uint16_t adcBuff[40];

volatile uint8_t DMA_end = 0;

/*********************************************************************
 * @fn      DebugInit
 *
 * @brief   调试初始化(扫描模式使用PB7打印)
 *
 * @return  none
 */
void DebugInit(void)
{
    GPIOB_SetBits(GPIO_Pin_7);
    GPIOB_ModeCfg(GPIO_Pin_4, GPIO_ModeIN_PU);
    GPIOB_ModeCfg(GPIO_Pin_7, GPIO_ModeOut_PP_5mA);
    UART0_DefInit();
}

/*********************************************************************
 * @fn      main
 *
 * @brief   主函数
 *
 * @return  none
 */
int main(void)
{
    uint8_t i;
    uint32_t temp = 0;
    uint32_t wait_cnt = 0;
    
    HSECFG_Capacitance(HSECap_18p);
    SetSysClock(SYSCLK_FREQ);

    /* 配置串口调试 */
    DebugInit();
    PRINT("Start @ChipID=%02X\n", R8_CHIP_ID);
    PRINT("ADC scan mode: 14 channels + DMA\n");

    GPIOA_ModeCfg(ADC_PIN[adc_ch_seq[0]] |
                      ADC_PIN[adc_ch_seq[1]] |
                      ADC_PIN[adc_ch_seq[2]] |
                      ADC_PIN[adc_ch_seq[3]] |
                      ADC_PIN[adc_ch_seq[4]] |
                      ADC_PIN[adc_ch_seq[5]] |
                      ADC_PIN[adc_ch_seq[6]] |
                      ADC_PIN[adc_ch_seq[7]] |
                      ADC_PIN[adc_ch_seq[8]] |
                      ADC_PIN[adc_ch_seq[9]] |
                      ADC_PIN[adc_ch_seq[10]] |
                      ADC_PIN[adc_ch_seq[11]] |
                      ADC_PIN[adc_ch_seq[12]] |
                      ADC_PIN[adc_ch_seq[13]],
                  GPIO_ModeIN_Floating);

    GPIOADigitalCfg(DISABLE, ADC_PIN[adc_ch_seq[0]] |
            ADC_PIN[adc_ch_seq[1]] |
            ADC_PIN[adc_ch_seq[2]] |
            ADC_PIN[adc_ch_seq[3]] |
            ADC_PIN[adc_ch_seq[4]] |
            ADC_PIN[adc_ch_seq[5]] |
            ADC_PIN[adc_ch_seq[6]] |
            ADC_PIN[adc_ch_seq[7]] |
            ADC_PIN[adc_ch_seq[8]] |
            ADC_PIN[adc_ch_seq[9]] |
            ADC_PIN[adc_ch_seq[10]] |
            ADC_PIN[adc_ch_seq[11]] |
            ADC_PIN[adc_ch_seq[12]] |
            ADC_PIN[adc_ch_seq[13]]);

    ADC_ExtSingleChSampInit(SampleFreq_4_or_2, ADC_PGA_0);     // 4M采样频率，0dB增益
    R8_ADC_CONVERT |= RB_ADC_SAMPLE_TIME;                      // 7个采样周期
    ADC_ChannelCfg(adc_ch_seq[0]);

    temp = (adc_ch_seq[1] << ADC_SCAN1_CH_IDX_1) |
           (adc_ch_seq[2] << ADC_SCAN1_CH_IDX_2) |
           (adc_ch_seq[3] << ADC_SCAN1_CH_IDX_3) |
           (adc_ch_seq[4] << ADC_SCAN1_CH_IDX_4) |
           (adc_ch_seq[5] << ADC_SCAN1_CH_IDX_5) |
           (adc_ch_seq[6] << ADC_SCAN1_CH_IDX_6) |
           (adc_ch_seq[7] << ADC_SCAN1_CH_IDX_7) |
           (adc_ch_seq[8] << ADC_SCAN1_CH_IDX_8);
    R32_ADC_SCAN_CFG1 = temp;
    temp = (adc_ch_seq[9] << ADC_SCAN2_CH_IDX_9) |
           (adc_ch_seq[10] << ADC_SCAN2_CH_IDX_10) |
           (adc_ch_seq[11] << ADC_SCAN2_CH_IDX_11) |
           (adc_ch_seq[12] << ADC_SCAN2_CH_IDX_12) |
           (adc_ch_seq[13] << ADC_SCAN2_CH_IDX_13);
    temp |= RB_ADC_SCAN_SEL | RB_ADC_IE_SCAN_END | ((ADC_SCAN_CH_NUM - 1) << 24); // RB_ADC_SCAN_NUM = ADC_SCAN_CH_NUM - 1
    R32_ADC_SCAN_CFG2 = temp;

    R32_ADC_DMA_BEG = (uint32_t)&adcBuff[0] & 0x1FFFF;
    R32_ADC_DMA_END = (uint32_t)&adcBuff[40] & 0x1FFFF;
    R8_ADC_CTRL_DMA |= RB_ADC_DMA_ENABLE | RB_SCAN_AUTO_TYPE;
    PFIC_EnableIRQ(ADC_IRQn);
    R8_ADC_CONVERT |= RB_ADC_START;  

    while(!DMA_end)
    {
        if(++wait_cnt >= 0x1000000) // 超时上限，避免ADC异常时无限等待
        {
            PRINT("ADC scan DMA wait timeout!\n");
            break;
        }
    }
    DMA_end = 0;

    for(i = 0; i < ADC_SCAN_CH_NUM; i++)
    {
        PRINT("%d:%d ", i, adcBuff[i]);
        PRINT("\n");
        adcBuff[i] = 0;
    }
    PRINT("\n");

    while(1);
    return 0;
}

/*********************************************************************
 * @fn      ADC_IRQHandler
 *
 * @brief   ADC中断函数
 *
 * @return  none
 */
__INTERRUPT
__HIGH_CODE
void ADC_IRQHandler(void) // adc中断服务程序
{
    if(R8_ADC_INT_FLAG & RB_ADC_IF_EOC)
    {
        ADC_ClearITFlag();
    }

    if(R32_ADC_SCAN_CFG2 & RB_ADC_IF_SCAN_END)
    {
        R32_ADC_SCAN_CFG2 |= RB_ADC_IF_SCAN_END;
        R32_ADC_DMA_BEG = (uint32_t)adcBuff & 0x1ffff;
        DMA_end = 1;
    }
}
